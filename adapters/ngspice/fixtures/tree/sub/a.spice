* a
.inc ../b.spice
