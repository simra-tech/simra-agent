* b
.include sub/a.spice
